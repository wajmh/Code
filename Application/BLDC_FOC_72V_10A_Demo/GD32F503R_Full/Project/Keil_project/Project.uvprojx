# Keil uVision project Project.uvprojx, settings and files
target GD32F50X (6210000::V6.21::ARMCLANG)
  device: GD32F503RE GigaDevice
  pack: GigaDevice.GD32F50x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER, GD32F50X, GD32F503, FW_DEBUG_ERR_REPORT
  c include: ..\..\Inc;..\..\..\..\..\FOC_SDK2.0\FOC_Topology\Inc;..\..\..\..\..\FOC_SDK2.0\FOC_Algorithm\Inc;..\..\..\..\..\FOC_SDK2.0\FOC_Driver\BLDC_FOC_72V_10A\GD32F503R\Inc;..\..\..\..\..\Firmware\GD32F50x_Firmware_Library\Firmware\CMSIS\GD\GD32F50x\Include;..\..\..\..\..\Firmware\GD32F50x_Firmware_Library\Firmware\CMSIS;..\..\..\..\..\Firmware\GD32F50x_Firmware_Library\Firmware\GD32F50x_standard_peripheral\Include;..\..\..\..\..\FOC_SDK2.0\FOC_Driver\BLDC_FOC_72V_10A\GD32F503R\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../Src/: gd32_foc_it.c main.c communication.c gd32_bldc_foc_eval.c gdfoc_config.c motor_protect.c systick.c
    ../../Inc/: gd32_bldc_foc_eval.h motor_para.h topology_para.h motor_protect.h control_para.h
  group FOC_Topology
    ../../../../../FOC_SDK2.0/FOC_Topology/Src/: angle.c motor_ctrl.c pwm_current.c
  group FOC_Algorithm
    ../../../../../FOC_SDK2.0/FOC_Algorithm/Src/: foc_math.c modulation.c smo_observer.lib vf_if_startup.lib aflux_observer.lib
  group FOC_Driver
    ../../../../../FOC_SDK2.0/FOC_Driver/BLDC_FOC_72V_10A/GD32F503R/Src/: foc_soft_delay.c motor_ctrl_driver.c angle_hall.c pwm_current_2shunt.c pwm_current_3shunt.c pwm_current_1shunt.c angle_encoder.c Uart4_drv.c Uart4_drv.h
    ../../Src/: Can_drv.c Can_drv.h Flash_drv.c Flash_drv.h Can_protocol.c Can_protocol.h
  group CMSIS
    ../../../../../Firmware/GD32F50x_Firmware_Library/Firmware/CMSIS/GD/GD32F50x/Source/: system_gd32f50x.c gd32f50x_err_report.c
  group Peripherals
    ../../../../../Firmware/GD32F50x_Firmware_Library/Firmware/GD32F50x_standard_peripheral/Source/: gd32f50x_adc.c gd32f50x_bkp.c gd32f50x_can.c gd32f50x_cau.c gd32f50x_cmp.c gd32f50x_crc.c gd32f50x_ctc.c gd32f50x_dac.c gd32f50x_dbg.c gd32f50x_dma.c gd32f50x_exmc.c gd32f50x_exti.c gd32f50x_fmc.c gd32f50x_fwdgt.c gd32f50x_gpio.c gd32f50x_hau.c gd32f50x_i2c.c gd32f50x_misc.c gd32f50x_pmu.c gd32f50x_rcu.c gd32f50x_rtc.c gd32f50x_spi.c gd32f50x_syscfg.c gd32f50x_timer.c gd32f50x_trigsel.c gd32f50x_trng.c gd32f50x_usart.c gd32f50x_wwdgt.c
  group Startup
    ../../../../../Firmware/GD32F50x_Firmware_Library/Firmware/CMSIS/GD/GD32F50x/Source/ARM/: startup_gd32f50x.s
software components: CMSIS:CORE 5.3.0
